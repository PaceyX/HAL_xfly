# Keil uVision project hal_xfly.uvprojx, settings and files
target xfly (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hal_xfly +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: .\APP;.\BSP;.\Hal_xfly\Src;.\Hal_xfly\Inc;.\Hal_xfly\Drivers\STM32F4xx_HAL_Driver\Inc;.\hal_xfly\Drivers\STM32F4xx_HAL_Driver\Src;.\Hal_xfly\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;.\Hal_xfly\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Hal_xfly\Drivers\CMSIS\Include;.\BSP\Src;.\BSP\Inc;.\APP\Src;.\APP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/STM32F4xx_HAL_Driver
    ./Hal_xfly/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Application/MDK-ARM
    ./Hal_xfly/MDK-ARM/: startup_stm32f407xx.s
  group Application/User
    ./Hal_xfly/Src/: adc.c dma.c gpio.c i2c.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group APP
    ./APP/Src/: task.c app_runflag.c app_timer.c
  group BSP
    ./BSP/Src/: bsp.c led_bsp.c iic_bsp.c spi_bsp.c gpio_bsp.c usart_bsp.c usart1_bsp.c usart3_bsp.c uart5_bsp.c pwm_bsp.c hmc5983.c max21100.c ultrasonic.c ms5611.c w25q32.c flash_bsp.c
  group Drivers/CMSIS
    ./Hal_xfly/Src/: system_stm32f4xx.c
